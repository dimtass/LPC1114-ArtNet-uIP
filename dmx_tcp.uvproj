# Keil uVision project dmx_tcp.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group StartUp
    ./: startup_LPC11xx.s
    ./src/: system_LPC11xx.c
  group Source Files
    ./: main.c
  group Documentation
    ./: Abstract.txt
  group inc
    ./inc/: common.h LPC11xx.h system_LPC11xx.h uart.h clock-arch.h dm9k_uip.h uip-conf.h dmx.h connection.h udp_connection.h artnet.h IAP.h sACN.h
  group src
    ./src/: Retarget.c uart.c clock-arch.c dm9k_uip.c dmx.c connection.c udp_connection.c artnet.c IAP.c sACN.c
  group New Group
    ./uip/: clock.h lc.h lc-addrlabels.h lc-switch.h psock.c psock.h pt.h timer.c timer.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip-fw.c uip-fw.h uiplib.c uiplib.h uip-neighbor.c uip-neighbor.h uipopt.h uip-split.c uip-split.h
target LPC1114 RAM (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x1c00
  memory RVCT9: RAM 0x10001c00 size 0x400
target LPC1114 Flash (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: as above
  output: dmx_tcp +hex
  c flags: Optim=4 oTime=1
  c include: .\inc;.\src;.\uip
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1fe0
